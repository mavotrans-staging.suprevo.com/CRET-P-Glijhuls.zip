Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-04-06T08:18:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 06 08:18:36 2023 * Host: MAV-DTP-TESSA * Database: C:\Users\T6FAF~1.PLA\AppData\Local\Temp\fdaae377-05c3-4360-8a65-4f585b0c56b6\758ae953-43d2-44c4-8b63-77e954f2e979\ifc * Database version: 5507 * Database creation date: Thu Apr 06 08:18:36 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 06 08:18:36 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 06 08:18:36 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - BCB_ProjectFolder: C:\Users\t.plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\10-Dwarskrachtdeuvels; Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; BCB_ProjectFolder: C:\Users\t.plat\OneDrive - Mavotrans\BIM T&D\3. Modellen Mavotrans\1. Betonkoppelsystemen\10-Dwarskrachtdeuvels; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcBuildingElementProxy: 101617, NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20:101617_CRET-P/20-170:331036
In: Level 0
Type - Description: CRET-P/20-170; Material: Kunststof, plastic
Type - Constraints - Default Elevation: 100 mm
Type - Construction - h_d: 25 mm; h_h: 25 mm; h_l: 170 mm; h_l_eff: 150 mm; h_t: 2 mm; h_w: 25 mm; p_l: 70 mm; p_t: 4 mm; x1: 12 mm; x2: 10 mm; x3: 21 mm
Type - Dimensions - Afmeting bevestigingsflens | Dimensions mounting flange (mm): 70x70; Lengte | Length (mm): 170 mm; Netto diepte | Net depth (mm): 150 mm
Type - Graphics - x4: yes
Type - Identity Data - Artikelnummer | Article number: 101617; Beschrijving | Description: CRET-P/20-170; Laatste versie | Last version: 31-03-2023; Leverancier | Supplier: Mavotrans; NL-SfB code: 28; Opmerkingen | Comments: Huls | Sleeve; Revisie | Revision: Rev0; Technische data | Technical data: Raadpleeg de gekoppelde webpagina | Please refer to linked URL; Tekenaar | Draftsman: T. Plat; Type Name: 101617_CRET-P/20-170; URL: https://mavotrans.nl/cret-p.html; Voorwaarden | Disclaimer: Raadpleeg de gekoppelde webpagina en controleer voor gebruik van dit BIM-model op de laatst beschikbare revisie. De modellen, geometrie, data en parameterwaarden zijn met de grootste zorg bepaald. Desalniettemin bestaat de mogelijkheid op onjuistheden. Elke aansprakelijkheid hiervoor wordt van de hand gewezen, hoewel melding op prijs wordt gesteld. © Mavotrans, 2022 | Please refer to linked URL and check for the latest available model revision. The models, geometry and parameter values have been determined with the greatest care. Still, they are subject to errors. Mavotrans cannot be held liable in any way. However, we do appreciate your feedback. © Mavotrans, 2022; Zijdelingse verplaatsing / Lateral displacement: 0 mm
Type - Materials and Finishes - Material: Kunststof, plastic
Type - Other - Category: Generic Models; Family Name: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20
Type - Pset_BuildingElementProxyCommon - Reference: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20:101617_CRET-P/20-170
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20:101617_CRET-P/20-170
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 200 mm; Level: Level: Level 0; Offset from Host: 200 mm; Schedule Level: Level: Level 0; Work Plane: Level : Level 0
Dimensions - Area: 0.0181946 m2; Volume: 0.0000514932 m3
Other - Family: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101617_CRET-P/20-170; Family and Type: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101617_CRET-P/20-170; Type: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101617_CRET-P/20-170; Type Id: NLRSnl_28_GM_WPB_101-CRET-P-J-V20_R20: 101617_CRET-P/20-170
Phasing - Phase Created: New Construction
